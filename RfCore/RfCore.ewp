# IAR project RfCore.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: kernel\inc; clock\inc; uart\inc; hc-12\inc; helpers\inc; $PROJ_DIR$
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: RfCore.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    clock/src/: clock.c
    clock/inc/: clock.h
    hc-12/src/: hc-12.c
    hc-12/inc/: hc-12.h
    helpers/src/: helpers.c
    helpers/inc/: helpers.h
    kernel/src/: kernel.c
    kernel/inc/: kernel.h
    ./: main.c platform.h STM8S003F3.h
    uart/src/: uart.c
    uart/inc/: uart.h
